# Keil uVision project STM32F0DISCOVERY.uvproj, settings and files
target STM32F0DISCOVERY (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F0DISCOVERY
  c flags: Optim=1
  c define: STM32F0DISCOVERY,STM32F0XX
  c include: ..\inc;..\lib\CMSIS\inc;..\lib\STM32F0\inc;..\lib\BSP\STM32F0DISCOVERY
  asm define: STM32F0DISCOVERY,STM32F0XX
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../lib/STM32F0/startup/keil/: startup_stm32f0xx.s
    ../lib/STM32F0/src/: system_stm32f0xx.c
  group src
    ../src/blink/: blink.cpp
  group SSAU
    ./../src/: SSAU.cpp
  group BSP
    ./../lib/BSP/STM32F0DISCOVERY/: stm32f0_discovery.c
