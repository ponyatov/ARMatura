# Keil uVision project STM32F103EMU.uvproj, settings and files
target STM32F103EMU (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103EMU
  c flags: Optim=1
  c define: STM32EMU103,STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\lib\CMSIS\inc;..\lib\STM32F10x\inc;..\lib\BSP\STM32EMU103
  asm define: STM32EMU103,STM32F10X_MD,USE_STDPERIPH_DRIVER
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../lib/STM32F10x/startup/keil/: startup_stm32f10x_md.s
    ../lib/STM32F10x/src/: system_stm32f10x.c
  group src
    ./../src/blink/: blink.cpp
  group CMSIS
    ../lib/STM32F10x/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group SSAU
    ../src/: SSAU.cpp
  group BSP
    ./../lib/BSP/STM32EMU103/: STM32emu103.c
