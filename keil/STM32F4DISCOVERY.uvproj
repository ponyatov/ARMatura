# Keil uVision project STM32F4DISCOVERY.uvproj, settings and files
target STM32F4DISCOVERY sRam (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4DISCOVERY
  c flags: Optim=1
  c define: STM32F4DISCOVERY,STM32F40XX,USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c include: ..\inc;..\lib\CMSIS\inc;..\lib\STM32F4\inc;..\lib\BSP\STM32F4DISCOVERY
  asm define: as above
  asm include: as above
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10004000 size 0xc000
  group startup
    ./../lib/STM32F4/src/: system_stm32f4xx.c
    ../lib/STM32F4/startup/keil/: startup_stm32f40xx.s
  group CMSIS
    ../lib/STM32F4/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
  group src
    ./../src/blink/: blink.cpp
  group SSAU
    ./../src/: SSAU.cpp
  group BSP
    ../lib/BSP/STM32F4DISCOVERY/: stm32f4_discovery.c
  group config
    ./../inc/: SSAU.h
    ./: Dbg_RAM_STM32F407.ini
target STM32F4DISCOVERY Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: STM32F4DISCOVERY
  c flags: Optim=1
  c define: STM32F4DISCOVERY,USE_STDPERIPH_DRIVER,STM32F4XX MANGUSTA_DISCOVERY HSE_VALUE=8000000UL
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
