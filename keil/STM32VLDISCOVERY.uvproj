# Keil uVision project STM32VLDISCOVERY.uvproj, settings and files
target STM32VLDISCOVERY (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32VLDISCOVERY
  c flags: Optim=1
  c define: STM32VLDISCOVERY,STM32F10X_LD_VL,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\lib\CMSIS\inc;..\lib\STM32F10x\inc;..\lib\BSP\STM32VLDISCOVERY
  asm define: STM32VLDISCOVERY,STM32F10X_LD_VL,USE_STDPERIPH_DRIVER
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ./../lib/STM32F10x/src/: system_stm32f10x.c
    ./../lib/STM32F10x/startup/keil/: startup_stm32f10x_ld_vl.s
  group CMSIS
    ./../lib/STM32F10x/src/: stm32f10x_gpio.c
  group src
    ./../src/blink/: blink.cpp
  group SSAU
    ./../src/: SSAU.cpp
  group BSP
    ./../lib/BSP/STM32VLDISCOVERY/: STM32vldiscovery.c
